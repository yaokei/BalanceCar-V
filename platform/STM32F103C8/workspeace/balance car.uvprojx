# Keil uVision project balance car.uvprojx, settings and files
target Balance Car (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: balance car +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --gnu
  c include: ..\common\mathematics\math;..\common\mathematics\matrix;..\common\mathematics\filter;..\common\mathematics\limit;..\common\mathematics\geo;..\common\modules\control;..\common\modules\estimator;..\common\peripheral\encoder;..\common\peripheral\mavlink;..\common\peripheral\mavlink\mavrelated;..\common\peripheral\mavlink\v1.0;..\common\peripheral\mavlink\v1.0\common;..\common\peripheral\mpu6050;..\common\peripheral\rgb_led;..\drivers;..\libraries\inc;..\system_app;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Platform
    ../system_app/: sensor.c task.c main.cpp parameters.c
  group Drivers
    ../drivers/: system_init.c sys_clock_config.c flash.c i2c_init.c pwm.c time.c usart.c usart1.c
  group Algoritnm
    ../common/modules/control/: control.c
    ../common/modules/estimator/: attitude_estimator.c
    ../common/mathematics/filter/: ComFilter.c
  group Peripheral
    ../common/peripheral/mavlink/: mavlink.cpp
    ../common/peripheral/mpu6050/: mpu6050.c
    ../common/peripheral/rgb_led/: rgb_led.c
    ../common/peripheral/encoder/: encoder.c
  group MavRelated
    ../common/peripheral/mavlink/mavrelated/: param.c platform.cpp topics.cpp
  group Chip
    ../libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CM&START
    ../CMSIS/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
